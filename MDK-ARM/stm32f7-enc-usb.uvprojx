# Keil uVision project stm32f7-enc-usb.uvprojx, settings and files
target stm32f7-enc-usb (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CLOCK(12000000) FPU3(SFPU) ELITTLE CPUTYPE("Cortex-M7")
  output: stm32f7-enc-usb
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src/drivers;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F7xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_bot.c usbd_msc.c usbd_msc_scsi.c usbd_msc_data.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff_gen_drv.c ff.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Application/User
    ../Src/: fatfs.c usbd_conf.c main.c usbd_desc.c stm32f7xx_hal_msp.c stm32f7xx_it.c bsp_driver_sd.c usb_device.c usbd_storage_if.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_usb.c stm32f7xx_hal.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_sd.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_dma.c stm32f7xx_hal_pcd.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_rcc.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
software components: CMSIS:CORE 4.1.0
